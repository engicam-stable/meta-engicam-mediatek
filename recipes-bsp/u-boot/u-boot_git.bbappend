FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-defconfig-for-genio-720-smarcore-evb-ufs.patch"

