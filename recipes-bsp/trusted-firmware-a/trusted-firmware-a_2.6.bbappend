FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-support-for-w25q256jweiq-spi-nor-in-spi-single.patch"

